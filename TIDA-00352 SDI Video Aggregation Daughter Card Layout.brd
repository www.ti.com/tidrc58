# Allegro board TIDA-00352 SDI Video Aggregation Daughter Card Layout.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_DECOUPLE1: length 2.5
  TOP w0.508: v1(75.68,80.9) C69.1 R105.2 R102.1
GND_DECOUPLE2: length 2.6
  TOP w0.508: v1(74.82,74.82) C63.1 R97.2 75.68,76.58 R99.1
GND_DECOUPLE3: length 2.5
  TOP w0.508: v1(75.68,34.54) C81.1 R125.2 R122.1
GND_DECOUPLE4: length 2.6
  TOP w0.508: v1(74.82,28.47) C75.1 R117.2 75.68,30.23 R119.1
3P3V: length 12.8
  TOP w0.508: R141.1 v1(99.69,148.59)
  L4-PWR2 w0.508: JMP4.2 74.66,104.14 ; JMP4.2 73.66,103.14 ; JMP4.2 73.66,105.14 ; JMP4.2 72.66,104.14 ; JMP3.2 73.66,58.15 ; JMP3.2 74.66,57.15 ; JMP3.2 72.66,57.15 ; JMP3.2 73.66,56.15 ; 72.66,16.51 JMP2.2 ; JMP2.2 73.66,15.51 ; JMP2.2 74.66,16.51 ; JMP2.2 73.66,17.51
  vias: v1(87.63,110.49) v1(87.63,107.95) v1(87.63,106.68) v1(87.63,105.41) v1(88.27,104.77) v1(88.9,110.49) v1(88.9,109.22) v1(88.9,107.95) v1(88.9,106.68) v1(88.9,105.41) v1(89.53,111.76) v1(90.17,112.39) v1(90.17,111.12) v1(90.81,111.76)
3P3V_0034: length 4.3
  TOP w0.508: JMP4.1 73.66,102.67 ; JMP4.1 73.66,100.53 ; JMP4.1 74.73,101.6 ; JMP4.1 72.59,101.6
3P3V_101: length 4.3
  TOP w0.508: 72.59,13.97 JMP2.1 ; JMP2.1 74.73,13.97 ; JMP2.1 73.66,15.04 ; JMP2.1 73.66,12.9
3P3V_0202: length 4.3
  TOP w0.508: JMP3.1 74.73,54.61 ; JMP3.1 73.66,53.54 ; JMP3.1 72.59,54.61 ; JMP3.1 73.66,55.68
3P3V_LMH0034: length 28.7
  TOP w0.508: R75.1 v1(118.11,34.16) ; 126.68,139.32 v1(127.89,139.32) C2.1 ; R52.1 v1(118.11,72.26) ; C32.1 v1(127.89,63.12) U5.2 ; R73.1 v1(118.11,29.72) ; R27.1 v1(118.11,105.92) ; R48.1 v1(118.11,60.07) ; C47.1 v1(127.89,25.02) U7.2 ; R29.1 v1(118.11,110.36) ; R25.1 v1(118.11,98.17) ; C31.1 v1(120.65,63.12) U5.15 ; R2.1 v1(118.11,136.27) ; 121.73,139.32 v1(120.65,139.32) C1.1 ; U3.15 v1(120.65,101.22) C16.1 ; R1.1 v1(123.19,128.27) ; R47.1 v1(123.19,52.07) ; C17.1 v1(127.89,101.22) U3.2 ; R4.1 v1(118.11,144.02) ; R70.1 v1(123.19,13.97) ; U7.15 v1(120.65,25.02) C46.1 ; R6.1 v1(118.11,148.46) ; R24.1 v1(123.19,90.17) ; R50.1 v1(118.11,67.82) ; R71.1 v1(118.11,21.97)
  vias: v1(79.38,103.5) v1(79.38,99.69) v1(80.01,104.14) v1(80.01,99.06) v1(80.64,104.77) v1(80.64,103.5) v1(80.64,102.23) v1(80.64,100.97) v1(80.64,99.69) v1(81.28,99.06)
3P3V_LMH0202: length 23.9
  TOP w0.305: R130.2 v1(80.64,31.24)
  TOP w0.508: R108.2 v1(80.52,81.15) ; v1(83.44,31.62) 82.93,32.13 C84.1 ; R95.2 v1(89.03,78.49) ; v1(88.15,74.93) R93.2 R94.2 ; R115.2 88.18,32.16 88.93,32.16 v1(89.03,32.26) ; v1(86.23,80.9) 86.49,81.15 C71.1 ; C72.1 82.93,78.49 v1(83.44,77.98) ; C83.1 86.49,34.8 v1(86.23,34.54) ; R109.2 v1(80.64,77.6) ; v1(88.15,28.57) R113.2 R114.2 ; R129.2 v1(80.52,34.8)
  BOTTOM w0.305: v1(83.44,31.62) 83.64,31.42 U10.13 ; v1(86.23,34.54) 85.71,34.03 U10.9 ; U9.13 83.64,77.78 v1(83.44,77.98) ; U9.9 85.71,80.38 v1(86.23,80.9)
  BOTTOM w0.508: R110.2 v1(74.93,77.47) ; R128.2 v1(74.93,31.11) ; R96.2 v1(88.91,81.15) ; R127.2 v1(74.92,33.78) ; R107.2 v1(74.8,80.14) ; R116.2 v1(88.15,35.57)
  vias: v1(79.38,56.52) v1(79.38,52.7) v1(80.01,57.15) v1(80.01,52.07) v1(80.64,57.78) v1(80.64,56.52) v1(80.64,55.24) v1(80.64,53.97) v1(80.64,52.7) v1(81.28,52.07)
3P3V_LVDS101: length 16.9
  TOP w0.508: 121.73,93.6 v1(120.65,93.6) C25.1 ; v1(130.81,16.64) C56.1 R84.1 v1(130.81,17.53) ; v1(130.81,93.73) R38.1 C26.1 v1(130.81,92.84) ; C40.1 v1(120.65,55.5) U6.8 ; C55.1 v1(120.65,17.4) 121.73,17.4 ; C10.1 v1(120.65,131.7) U2.8 ; v1(130.81,130.94) C11.1 R15.1 v1(130.81,131.83) ; v1(130.81,55.63) R61.1 C41.1 v1(130.81,54.74)
  vias: v1(79.38,15.88) v1(79.38,12.07) v1(80.01,16.51) v1(80.01,11.43) v1(80.64,17.14) v1(80.64,15.88) v1(80.64,14.61) v1(80.64,13.34) v1(80.64,12.07) v1(81.28,11.43)
3P3V_REG_TRIM: length 2.2
  TOP w0.381: R137.1 v1(81.91,109.22)
  BOTTOM w0.381: v1(81.91,109.22) R137.1
3P3VREG_ADJ: length 3.8
  TOP w0.381: R137.2 R136.2 86.33,109.34 U11.16
3P3VREG_SS: length 2.4
  TOP w0.381: C106.1 83.06,113 U11.15
/CD/MUTE1: length 23.8
  TOP w0.279: R2.2 R3.1 C3.1 U1.16 v1(122.81,138.05) ; Q1.1 v1(117.01,130.18)
  BOTTOM w0.279: v1(117.01,130.18) 117.75,129.44 117.75,129.44 118.92,128.27 122.05,128.27 125.86,132.08 125.86,134.62 122.81,137.67 v1(122.81,138.05)
/CD/MUTE2: length 23.8
  TOP w0.279: R25.2 R26.1 C18.1 U3.16 v1(122.81,99.95) ; Q2.1 v1(117.01,92.08)
  BOTTOM w0.279: v1(117.01,92.08) 118.92,90.17 122.05,90.17 125.86,93.98 125.86,96.52 122.81,99.57 v1(122.81,99.95)
/CD/MUTE3: length 23.9
  TOP w0.279: R48.2 R49.1 C33.1 U5.16 v1(122.81,61.85) ; Q3.1 v1(117.01,53.98)
  BOTTOM w0.279: v1(122.81,61.85) 122.81,61.47 125.86,58.42 125.86,55.75 122.17,52.07 118.92,52.07 v1(117.01,53.98)
/CD/MUTE4: length 23.9
  TOP w0.279: R71.2 R72.1 C48.1 U7.16 v1(122.81,23.75) ; Q4.1 v1(117.01,15.88)
  BOTTOM w0.279: v1(122.81,23.75) 122.81,23.37 125.86,20.32 125.86,17.65 122.17,13.97 118.92,13.97 v1(117.01,15.88)
/SDI1_MON1_IN: length 3.2
  TOP w0.14: v1(77.35,79.25) R105.1 C70.2
  BOTTOM w0.14: U9.6 78.88,78.91 77.68,78.91 v1(77.35,79.25) C70.2
/SDI2_MON2_IN: length 3.2
  TOP w0.14: v1(77.35,76.6) R99.2
  BOTTOM w0.14: U9.2 78.87,76.3 77.65,76.3 v1(77.35,76.6) R99.2
/SDI3_MON3_IN: length 3.2
  TOP w0.14: R125.1 v1(77.35,32.89)
  BOTTOM w0.14: U10.6 78.88,32.56 77.68,32.56 v1(77.35,32.89) C82.2
/SDI4_MON4_IN: length 3.2
  TOP w0.14: v1(77.35,30.24) R119.2
  BOTTOM w0.14: U10.2 78.87,29.95 77.65,29.95 v1(77.35,30.24) R119.2
/SDO1_OUT: length 5.1
  TOP w0.102: v1(86.23,79.88) 86.61,80.26 L8.1
  BOTTOM w0.102: R96.1 L8.1 87.08,80.29 86.64,80.29 v1(86.23,79.88) 86.23,79.38 85.94,79.08 U9.11
/SDO2_OUT: length 4.8
  TOP w0.102: v1(86.23,76.71) R94.1 L6.1
  BOTTOM w0.102: L6.1 86.61,77.6 86.26,77.24 86.26,76.73 v1(86.23,76.71) 86,76.48 U9.15
/SDO3_OUT: length 5.1
  TOP w0.102: v1(86.23,33.53) 86.61,33.91 L12.1
  BOTTOM w0.102: U10.11 85.94,32.73 86.23,33.02 v1(86.23,33.53) 86.64,33.93 87.08,33.93 L12.1 R116.1
/SDO4_OUT: length 4.8
  TOP w0.102: v1(86.23,30.35) R114.1 L10.1
  BOTTOM w0.102: U10.15 86,30.12 v1(86.23,30.35) 86.26,30.38 86.26,30.89 86.61,31.24 L10.1
/SDO_MON1_OUT: length 2.4
  TOP w0.102: L8.2 v1(88.9,80.26) C68.1
  BOTTOM w0.102: L8.2 v1(88.9,80.26)
/SDO_MON1_TERM: length 1.3
  TOP w0.102: C68.2 91.34,81.14 R106.2
/SDO_MON2_OUT: length 2.4
  TOP w0.102: L6.2 v1(88.9,77.6) C64.1
  BOTTOM w0.102: L6.2 v1(88.9,77.6)
/SDO_MON2_TERM: length 1.3
  TOP w0.102: C64.2 91.34,76.72 R101.2
/SDO_MON3_OUT: length 2.4
  TOP w0.102: L12.2 v1(88.9,33.91) C80.1
  BOTTOM w0.102: L12.2 v1(88.9,33.91)
/SDO_MON3_TERM: length 1.3
  TOP w0.102: C80.2 91.34,34.79 R126.2
/SDO_MON4_OUT: length 2.4
  TOP w0.102: C76.1 v1(88.9,31.24) L10.2
  BOTTOM w0.102: L10.2 v1(88.9,31.24)
/SDO_MON4_TERM: length 1.3
  TOP w0.102: C76.2 91.34,30.37 R121.2
AEC+1: length 1.4
  TOP w0.279: U1.7 126.95,145.4 C6.1
AEC+2: length 1.6
  TOP w0.279: C21.1 128.16,107.57 U3.7
AEC+3: length 1.6
  TOP w0.279: U5.7 128.16,69.47 C36.1
AEC+4: length 1.6
  TOP w0.279: U7.7 128.16,31.37 C51.1
AEC-1: length 1.5
  TOP w0.508: 126.68,146.94 127.52,146.94 C6.2
AEC-2: length 1.6
  TOP w0.508: C21.2 128.16,108.84 126.68,108.84
AEC-3: length 1.6
  TOP w0.508: C36.2 128.16,70.74 U5.8
AEC-4: length 1.6
  TOP w0.508: U7.8 128.16,32.64 C51.2
BYPASS1: length 3.7
  TOP w0.279: R6.2 R8.1 C8.1 119.93,146.71 120.55,146.71 120.78,146.94 121.73,146.94
BYPASS2: length 3.7
  TOP w0.279: 121.73,108.84 120.78,108.84 120.55,108.61 119.93,108.61 C23.1 R31.1 R29.2
BYPASS3: length 3.7
  TOP w0.279: R52.2 R54.1 C38.1 119.93,70.51 120.55,70.51 120.78,70.74 U5.9
BYPASS4: length 3.7
  TOP w0.279: U7.9 120.78,32.64 120.55,32.41 119.93,32.41 C53.1 R77.1 R75.2
CAMERA1_BNC_INPUT: length 5.1
  TOP w0.102: J3.1 R14.2
CAMERA1_COMMON_MODE: length 2.6
  TOP w0.279: U2.3 128.03,134.24 R22.1
CAMERA1_LVDSN: length 14.6
  TOP w0.279: v1(115.83,137.59) 114.81,137.59 R21.1 ; U2.6 121.61,134.12 v1(120.19,134.12)
  BOTTOM w0.14: v1(115.83,137.59) 115.83,137.98 115.9,138.05 116.07,138.05 116.35,138.34 116.72,138.34 117.18,137.88 117.18,135.64 118.19,134.64 121.28,134.64 121.63,134.3 121.63,133.88 121.13,133.38 120.71,133.38 120.64,133.45 120.19,133.9 v1(120.19,134.12)
CAMERA1_LVDSP: length 14.6
  TOP w0.279: v1(115.83,138.63) 114.81,138.63 R16.1 ; v1(120.19,133.09) 121.61,133.09 U2.7
  BOTTOM w0.14: v1(115.83,138.63) 116.84,138.63 117.47,138 117.47,135.76 118.31,134.93 121.41,134.93 121.92,134.42 121.92,133.76 121.25,133.09 v1(120.19,133.09)
CAMERA1_SE_INPUT: length 4.6
  TOP w0.102: R20.1 128.75,133.85 C13.2 ; C13.2 U2.2 ; C13.2 128.75,132.09 R15.2
CAMERA1_VBB: length 3.5
  TOP w0.279: U2.4 126.89,135.71 C15.1 128.41,136.65 R22.2
CAMERA1N_INPUT: length 112.6
  TOP w0.14: v1(42.06,69.24) 42.06,68.38 42.79,67.65 56.73,67.65 73.66,84.58 77.5,84.58 100.29,107.37 100.29,130.57 107.69,137.97 108.46,137.97 R19.2
  BOTTOM w0.14: v1(42.06,69.24) 42.4,69.58 42.4,70.35 42.26,70.48 J1.K30
CAMERA1N_SMA_OUT: length 5.1
  TOP w0.279: R23.2 J4.1 109.85,131.5
CAMERA1P_INPUT: length 112.5
  TOP w0.14: R17.2 108.46,138.26 107.57,138.26 100,130.69 100,107.49 77.38,84.87 73.54,84.87 56.61,67.94 42.91,67.94 42.35,68.5 42.35,68.72 42.51,68.87 42.73,68.87 v1(43.1,69.24)
  BOTTOM w0.14: v1(43.1,69.24) 42.69,69.65 42.69,70.35 42.83,70.48 J1.K31
CAMERA1P_SMA_OUT: length 5.1
  TOP w0.279: R11.1 J2.1 109.85,144.73
CAMERA2_BNC_INPUT: length 5.1
  TOP w0.102: J6.1 R41.1
CAMERA2_COMMON_MODE: length 2.6
  TOP w0.279: U4.3 128.03,96.14 R45.1
CAMERA2_LVDSN: length 14.6
  TOP w0.279: v1(120.19,96.02) 121.61,96.02 U4.6 ; R44.1 114.81,99.49 v1(115.83,99.49)
  BOTTOM w0.14: v1(115.83,99.49) 115.83,99.88 115.9,99.95 116.07,99.95 116.35,100.24 116.72,100.24 117.18,99.78 117.18,97.54 118.19,96.54 121.28,96.54 121.63,96.2 121.63,95.78 121.13,95.28 120.71,95.28 120.64,95.35 120.19,95.8 v1(120.19,96.02)
CAMERA2_LVDSP: length 14.6
  TOP w0.279: U4.7 121.61,94.99 v1(120.19,94.99) ; R39.1 114.81,100.53 v1(115.83,100.53)
  BOTTOM w0.14: v1(115.83,100.53) 116.84,100.53 117.47,99.9 117.47,97.66 118.31,96.83 121.41,96.83 121.92,96.32 121.92,95.66 121.25,94.99 v1(120.19,94.99)
CAMERA2_SE_INPUT: length 4.6
  TOP w0.102: R43.1 128.75,95.75 C28.2 ; C28.2 U4.2 ; C28.2 128.75,93.99 R38.2
CAMERA2_VBB: length 3.5
  TOP w0.279: R45.2 128.41,98.55 C30.1 126.89,97.61 U4.4
CAMERA2N_INPUT: length 103.1
  TOP w0.14: R42.2 108.46,99.87 107.61,99.87 95.25,87.5 95.25,74.93 85.05,64.73 35.55,64.73 31.9,68.38 v1(31.9,69.24)
  BOTTOM w0.14: v1(31.9,69.24) 32.24,69.58 32.24,70.35 32.1,70.48 J1.K22
CAMERA2N_SMA_OUT: length 5.1
  TOP w0.279: R46.2 J7.1 109.85,93.4
CAMERA2P_INPUT: length 103.1
  TOP w0.14: v1(32.94,69.24) 32.57,68.87 32.35,68.87 32.19,68.72 32.19,68.5 35.67,65.02 84.93,65.02 94.96,75.05 94.96,87.62 107.49,100.16 108.46,100.16 R40.2
  BOTTOM w0.14: J1.K23 32.67,70.48 32.53,70.35 32.53,69.65 v1(32.94,69.24)
CAMERA2P_SMA_OUT: length 5.1
  TOP w0.279: 109.85,106.63 J5.1 R34.1
CAMERA3_BNC_INPUT: length 5.1
  TOP w0.102: J9.1 R64.1
CAMERA3_COMMON_MODE: length 2.6
  TOP w0.279: R68.1 128.03,58.04 U6.3
CAMERA3_LVDSN: length 14.6
  TOP w0.279: v1(120.19,57.92) 121.61,57.92 U6.6 ; v1(115.83,61.39) 114.81,61.39 R67.1
  BOTTOM w0.14: v1(115.83,61.39) 115.83,61.78 115.9,61.85 116.07,61.85 116.35,62.14 116.72,62.14 117.18,61.68 117.18,59.44 118.19,58.44 121.28,58.44 121.63,58.1 121.63,57.68 121.13,57.18 120.71,57.18 120.64,57.25 120.19,57.7 v1(120.19,57.92)
CAMERA3_LVDSP: length 14.6
  TOP w0.279: U6.7 121.61,56.89 v1(120.19,56.89) ; v1(115.83,62.43) 114.81,62.43 R62.1
  BOTTOM w0.14: v1(115.83,62.43) 116.84,62.43 117.47,61.8 117.47,59.56 118.31,58.73 121.41,58.73 121.92,58.22 121.92,57.56 121.25,56.89 v1(120.19,56.89)
CAMERA3_SE_INPUT: length 4.6
  TOP w0.102: C43.2 128.75,55.89 R61.2 ; C43.2 U6.2 ; C43.2 128.75,57.65 R66.1
CAMERA3_VBB: length 3.5
  TOP w0.279: U6.4 126.89,59.51 C45.1 128.41,60.45 R68.2
CAMERA3N_INPUT: length 97.7
  TOP w0.14: v1(16.66,69.24) 16.66,68.38 23.27,61.77 108.46,61.77 R65.2
  BOTTOM w0.14: J1.K10 16.86,70.48 17,70.35 17,69.58 v1(16.66,69.24)
CAMERA3N_SMA_OUT: length 5.1
  TOP w0.279: R69.2 J10.1 109.85,55.3
CAMERA3P_INPUT: length 97.7
  TOP w0.14: v1(17.7,69.24) 17.33,68.87 17.11,68.87 16.95,68.72 16.95,68.5 23.39,62.06 108.46,62.06 R63.2
  BOTTOM w0.14: v1(17.7,69.24) 17.29,69.65 17.29,70.35 17.43,70.48 J1.K11
CAMERA3P_SMA_OUT: length 5.1
  TOP w0.279: R57.1 J8.1 109.85,68.53
CAMERA4_BNC_INPUT: length 5.1
  TOP w0.102: J12.1 R87.1
CAMERA4_COMMON_MODE: length 2.6
  TOP w0.279: 126.68,19.94 128.03,19.94 R91.1
CAMERA4_LVDSN: length 14.6
  TOP w0.279: 121.73,19.94 121.61,19.82 v1(120.19,19.82) ; v1(115.83,23.29) 114.81,23.29 R90.1
  BOTTOM w0.14: v1(120.19,19.82) 120.19,19.6 120.64,19.15 120.71,19.08 121.13,19.08 121.63,19.58 121.63,20 121.28,20.34 118.19,20.34 117.18,21.34 117.18,23.58 116.72,24.04 116.35,24.04 116.07,23.75 115.9,23.75 115.83,23.68 v1(115.83,23.29)
CAMERA4_LVDSP: length 14.6
  TOP w0.279: R85.1 114.81,24.33 v1(115.83,24.33) ; U8.7 121.61,18.79 v1(120.19,18.79)
  BOTTOM w0.14: v1(120.19,18.79) 121.25,18.79 121.92,19.46 121.92,20.12 121.41,20.63 118.31,20.63 117.47,21.46 117.47,23.7 116.84,24.33 v1(115.83,24.33)
CAMERA4_SE_INPUT: length 4.6
  TOP w0.102: C58.2 128.75,19.55 R89.1 ; C58.2 U8.2 ; C58.2 128.75,17.79 R84.2
CAMERA4_VBB: length 3.5
  TOP w0.279: R91.2 128.41,22.35 C60.1 126.89,21.41 U8.4
CAMERA4N_INPUT: length 123.7
  TOP w0.14: R88.2 108.46,23.67 107.52,23.67 85.6,45.59 67.15,45.59 62.11,50.63 24.14,50.63 6.48,68.3 6.48,69.22 v1(6.5,69.24)
  BOTTOM w0.14: J1.K2 6.7,70.48 6.84,70.35 6.84,69.58 v1(6.5,69.24)
CAMERA4N_SMA_OUT: length 5.1
  TOP w0.279: R92.2 J13.1
CAMERA4P_INPUT: length 123.7
  TOP w0.14: R86.2 108.46,23.96 107.65,23.96 85.72,45.89 67.27,45.89 62.23,50.93 24.26,50.93 6.77,68.42 6.77,68.69 6.95,68.87 7.17,68.87 v1(7.54,69.24)
  BOTTOM w0.14: J1.K3 7.27,70.48 7.13,70.35 7.13,69.65 v1(7.54,69.24)
CAMERA4P_SMA_OUT: length 5.1
  TOP w0.279: R80.1 J11.1
CLI1: length 2.3
  TOP w0.279: U1.1 C4.1
CLI2: length 2.3
  TOP w0.279: U3.1 C19.1
CLI3: length 2.3
  TOP w0.279: U5.1 C34.1
CLI4: length 2.3
  TOP w0.279: U7.1 C49.1
EN: length 3.2
  TOP w0.279: R135.2 84.73,118.54 U11.11
LED1A: length 1.3
  TOP w0.279: D1.2 125.12,128.13 R1.2
LED1C: length 5
  TOP w0.279: Q1.3 119.5,128.52 121.03,127 D1.1
LED2A: length 1.3
  TOP w0.279: R24.2 125.12,90.03 D2.2
LED2C: length 5
  TOP w0.279: D2.1 121.03,88.9 119.51,90.42 Q2.3
LED3A: length 1.3
  TOP w0.279: R47.2 125.12,51.93 D3.2
LED3C: length 5
  TOP w0.279: D3.1 121.03,50.8 119.51,52.32 Q3.3
LED3P3VA: length 1.4
  TOP w0.279: D9.2 101.75,148.86 R141.2
LED4A: length 1.3
  TOP w0.279: R70.2 125.12,13.83 D4.2
LED4C: length 5
  TOP w0.279: D4.1 121.03,12.7 119.51,14.22 Q4.3
LED5V: length 1.4
  TOP w0.279: D8.2 78.89,148.86 R140.2
LED_LMH0034: length 1.4
  TOP w0.292: R139.2 77.95,105.04 D10.2
LED_LMH0202: length 1.4
  TOP w0.292: R134.2 77.95,58.05 D7.2
LED_LVDSA: length 1.4
  TOP w0.292: R133.2 77.95,17.41 D6.2
LMH0034_/SDI1: length 2.3
  TOP w0.102: C9.1 U1.5
LMH0034_/SDI2: length 2.3
  TOP w0.102: C24.1 U3.5
LMH0034_/SDI3: length 2.3
  TOP w0.102: C39.1 U5.5
LMH0034_/SDI4: length 2.3
  TOP w0.102: C54.1 U7.5
LMH0034_/SDO1: length 14.6
  TOP w0.279: U1.12 121.61,143.01 v1(120.19,143.01) ; v1(114.68,136.72) 114.41,136.44 R12.1
  BOTTOM w0.14: v1(114.68,136.72) 113.54,137.86 113.52,137.88 113.45,137.94 113.17,138.23 113.17,139.39 116.79,143.01 v1(120.19,143.01)
LMH0034_/SDO2: length 14.6
  TOP w0.279: v1(120.19,104.91) 121.61,104.91 U3.12 ; v1(114.68,98.62) 114.41,98.34 R35.1
  BOTTOM w0.14: v1(114.68,98.62) 113.54,99.76 113.52,99.78 113.45,99.84 113.17,100.13 113.17,101.29 116.79,104.91 v1(120.19,104.91)
LMH0034_/SDO3: length 14.6
  TOP w0.279: v1(120.19,66.81) 121.61,66.81 U5.12 ; R58.1 114.41,60.24 v1(114.68,60.52)
  BOTTOM w0.14: v1(114.68,60.52) 113.54,61.66 113.52,61.68 113.45,61.74 113.17,62.03 113.17,63.19 116.79,66.81 v1(120.19,66.81)
LMH0034_/SDO4: length 14.6
  TOP w0.279: U7.12 121.61,28.71 v1(120.19,28.71) ; R81.1 114.41,22.14 v1(114.68,22.42)
  BOTTOM w0.14: v1(120.19,28.71) 116.79,28.71 113.17,25.09 113.17,23.93 113.45,23.64 113.52,23.58 113.54,23.56 v1(114.68,22.42)
LMH0034_AC_IN1: length 2.1
  TOP w0.102: C7.2 U1.4
LMH0034_AC_IN2: length 2.1
  TOP w0.102: C22.2 126.68,103.76
LMH0034_AC_IN3: length 2.1
  TOP w0.102: C37.2 U5.4
LMH0034_AC_IN4: length 2.1
  TOP w0.102: C52.2 U7.4
LMH0034_IN1: length 3.1
  TOP w0.102: C7.1 130.45,141.99 R7.2 ; R7.2 R9.1 ; R7.2 L1.2
LMH0034_IN2: length 3.1
  TOP w0.102: L2.2 R30.2 ; R30.2 130.45,103.89 C22.1 ; R30.2 R32.1
LMH0034_IN3: length 3.1
  TOP w0.102: R53.2 130.45,65.79 C37.1 ; R53.2 R55.1 ; R53.2 L3.2
LMH0034_IN4: length 3.1
  TOP w0.102: C52.1 130.45,27.69 R76.2 ; L4.2 R76.2 ; R76.2 R78.1
LMH0034_SDI1: length 2
  TOP w0.102: R14.1 L1.1 R7.1
LMH0034_SDI2: length 2
  TOP w0.102: R30.1 L2.1 R37.1
LMH0034_SDI3: length 2
  TOP w0.102: R60.1 L3.1 R53.1
LMH0034_SDI4: length 2
  TOP w0.102: R76.1 L4.1 R83.1
LMH0034_SDO1: length 14.6
  TOP w0.279: v1(120.19,141.98) 121.61,141.98 U1.13 ; R13.1 114.39,139.79 114.41,139.76 v1(114.68,139.51)
  BOTTOM w0.14: v1(120.19,141.98) 119.44,142.72 116.91,142.72 113.46,139.27 113.46,138.35 113.58,138.23 114.48,138.23 114.68,138.42 v1(114.68,139.51)
LMH0034_SDO2: length 14.6
  TOP w0.279: R36.1 114.39,101.69 114.41,101.66 v1(114.68,101.41) ; v1(120.19,103.88) 121.61,103.88 121.73,103.76
  BOTTOM w0.14: v1(114.68,101.41) 114.68,100.32 114.48,100.13 113.58,100.13 113.46,100.25 113.46,101.17 116.91,104.62 119.44,104.62 v1(120.19,103.88)
LMH0034_SDO3: length 14.6
  TOP w0.279: v1(114.68,63.31) 114.41,63.56 114.39,63.59 R59.1 ; v1(120.19,65.78) 121.61,65.78 U5.13
  BOTTOM w0.14: v1(120.19,65.78) 119.44,66.52 116.91,66.52 113.46,63.07 113.46,62.15 113.58,62.03 114.48,62.03 114.68,62.22 v1(114.68,63.31)
LMH0034_SDO4: length 14.6
  TOP w0.279: U7.13 121.61,27.68 v1(120.19,27.68) ; v1(114.68,25.21) 114.41,25.46 114.39,25.49 R82.1
  BOTTOM w0.14: v1(114.68,25.21) 114.68,24.12 114.48,23.93 113.58,23.93 113.46,24.05 113.46,24.97 116.91,28.42 119.44,28.42 v1(120.19,27.68)
LMH0034_TERM1: length 0.9
  TOP w0.102: C9.2 R10.1
LMH0034_TERM2: length 0.9
  TOP w0.102: C24.2 R33.1
LMH0034_TERM3: length 0.9
  TOP w0.102: C39.2 R56.1
LMH0034_TERM4: length 0.9
  TOP w0.102: C54.2 R79.1
LVDS101_IN1: length 10.7
  TOP w0.102: C13.1 131.44,134.09 131.44,138.52 R18.2
LVDS101_IN2: length 10.7
  TOP w0.102: C28.1 131.44,95.99 131.44,100.42 R41.2
LVDS101_IN3: length 10.7
  TOP w0.102: R64.2 131.44,62.32 131.44,57.89 C43.1
LVDS101_IN4: length 10.7
  TOP w0.102: R87.2 131.44,24.22 131.44,19.79 C58.1
MONITOR1_SDI_OUTPUT: length 4.5
  BOTTOM w0.102: C67.2 J15.1
MONITOR1N_OUTPUT: length 44.9
  BOTTOM w0.14: C70.1 75.37,78.95 69.52,78.95 59.15,68.58 37.88,68.58 37.27,69.18 37.27,70.04 37.72,70.48 J1.K27
MONITOR1P_OUTPUT: length 44.9
  BOTTOM w0.14: C66.1 75.37,78.66 69.64,78.66 59.27,68.29 37.76,68.29 36.98,69.06 36.98,70.33 J1.K26
MONITOR2_SDI_OUTPUT: length 4.5
  BOTTOM w0.102: C62.2 J14.1
MONITOR2N_OUTPUT: length 56.8
  BOTTOM w0.14: J1.K19 27.69,70.48 27.04,69.84 27.04,68.01 29.03,66.01 60.73,66.01 71.02,76.3 75.37,76.3 C65.1
MONITOR2P_OUTPUT: length 56.8
  BOTTOM w0.14: C61.1 75.37,76.01 71.14,76.01 60.85,65.72 28.91,65.72 26.75,67.89 26.75,70.41 J1.K18
MONITOR3_SDI_OUTPUT: length 4.5
  BOTTOM w0.102: C79.2 J17.1
MONITOR3N_OUTPUT: length 76.6
  BOTTOM w0.14: J1.K15 22.48,70.48 22.03,70.04 22.03,66.64 25.17,63.5 50.67,63.5 72.36,41.81 72.36,34.37 74.14,32.59 75.37,32.59 C82.1
MONITOR3P_OUTPUT: length 76.6
  BOTTOM w0.14: C78.1 75.37,32.3 74.02,32.3 72.07,34.25 72.07,41.69 50.55,63.21 25.05,63.21 21.74,66.52 21.74,70.33 J1.K14
MONITOR4_SDI_OUTPUT: length 4.5
  BOTTOM w0.102: C74.2 J16.1
MONITOR4N_OUTPUT: length 86.8
  BOTTOM w0.14: C77.1 75.37,29.95 72.7,29.95 69.77,32.87 69.77,40.21 49.02,60.96 19.23,60.96 11.82,68.36 11.82,69.86 12.45,70.48 J1.K7
MONITOR4P_OUTPUT: length 86.8
  BOTTOM w0.14: C73.1 75.37,29.65 72.58,29.65 69.48,32.75 69.48,40.09 48.9,60.67 19.11,60.67 11.53,68.24 11.53,70.38 J1.K6
MUTEREF1: length 3.7
  TOP w0.279: R4.2 R5.1 C5.1 120.52,145.8 120.65,145.67 U1.10
MUTEREF2: length 3.7
  TOP w0.279: U3.10 120.65,107.57 120.52,107.7 C20.1 R28.1 R27.2
MUTEREF3: length 3.7
  TOP w0.279: U5.10 120.65,69.47 120.52,69.6 C35.1 R51.1 R50.2
MUTEREF4: length 3.7
  TOP w0.279: R73.2 R74.1 C50.1 120.52,31.5 120.65,31.37 U7.10
Net_10: length 0.9
  BOTTOM w0.241: 5.08,76.83 v1(4.45,77.47)
Net_11: length 0.9
  BOTTOM w0.241: 7.62,76.83 v1(6.98,77.47)
Net_12: length 0.9
  BOTTOM w0.152: 17.78,81.91 v1(18.41,82.55)
Net_14: length 0.9
  BOTTOM w0.152: 16.51,81.91 v1(17.15,82.55)
RREF1_1: length 2.5
  BOTTOM w0.279: R110.1 76.85,77.6 77.6,77.6 77.78,77.78 U9.4
RREF1_2: length 2.5
  BOTTOM w0.279: U10.4 77.78,31.42 77.6,31.24 76.85,31.24 R128.1
RREF2_1: length 2.4
  BOTTOM w0.279: R107.1 77.67,80.14 77.92,80.38 U9.8
RREF2_2: length 2.4
  BOTTOM w0.279: R127.1 77.67,33.78 77.92,34.03 U10.8
SD/HD1_1: length 3.3
  TOP w0.279: v1(83.44,76.71) R112.2 R109.1
  BOTTOM w0.279: U9.14 83.86,77.13 v1(83.44,76.71)
SD/HD1_2: length 3.3
  TOP w0.279: v1(83.44,30.35) R132.2 R130.1
  BOTTOM w0.279: U10.14 83.86,30.77 v1(83.44,30.35)
SD/HD2_1: length 3.5
  TOP w0.279: R108.1 R111.2 82.97,79.73 v1(83.31,79.73)
  BOTTOM w0.279: U9.10 v1(83.31,79.73)
SD/HD2_2: length 3.5
  TOP w0.279: R129.1 R131.2 82.97,33.38 v1(83.31,33.38)
  BOTTOM w0.279: U10.10 v1(83.31,33.38)
SDI1_MON1_IN: length 3.2
  TOP w0.14: R102.2 v1(77.35,78.36)
  BOTTOM w0.14: U9.5 78.85,78.62 77.61,78.62 v1(77.35,78.36) C66.2
SDI2_MON2_IN: length 3.2
  TOP w0.14: v1(77.35,75.71) R97.1
  BOTTOM w0.14: C61.2 v1(77.35,75.71) 77.65,76.01 78.87,76.01 U9.1
SDI3_MON3_IN: length 3.2
  TOP w0.14: R122.2 v1(77.35,32)
  BOTTOM w0.14: C78.2 v1(77.35,32) 77.61,32.27 78.85,32.27 U10.5
SDI4_MON4_IN: length 3.2
  TOP w0.14: v1(77.35,29.35) R117.1
  BOTTOM w0.14: C73.2 v1(77.35,29.35) 77.65,29.65 78.87,29.65 U10.1
SDO1_OUT: length 4.1
  TOP w0.102: R95.1 86.26,78.49 v1(86.23,78.46)
  BOTTOM w0.102: U9.12 86.05,78.43 86.08,78.46 v1(86.23,78.46) 86.26,78.49 R95.1 R103.1
SDO2_OUT: length 4.1
  TOP w0.102: R93.1 v1(86.23,75.82)
  BOTTOM w0.102: R98.1 R93.1 v1(86.23,75.82) 84.8,75.82 U9.16
SDO3_OUT: length 4.1
  TOP w0.102: R115.1 86.26,32.13 v1(86.23,32.11)
  BOTTOM w0.102: U10.12 86.05,32.08 86.08,32.11 v1(86.23,32.11) 86.26,32.13 R115.1 R123.1
SDO4_OUT: length 4.1
  TOP w0.102: R113.1 v1(86.23,29.46)
  BOTTOM w0.102: R118.1 R113.1 v1(86.23,29.46) 84.8,29.46 U10.16
SDO_MON1_OUT: length 76.5
  BOTTOM w0.102: L7.2 R103.2 88.9,79.38 97.79,88.27 97.79,107.95 106.74,116.9 111.82,116.9 118.75,123.83 C67.1
SDO_MON2_OUT: length 50.3
  BOTTOM w0.102: L5.2 R98.2 96.39,76.71 102.23,82.55 118.11,82.55 121.28,85.72 C62.1
SDO_MON3_OUT: length 52.6
  BOTTOM w0.102: C79.1 127.64,47.62 123.19,43.18 102.62,43.18 92.46,33.02 R123.2 L11.2
SDO_MON4_OUT: length 60.5
  BOTTOM w0.102: C74.1 122.56,9.53 119.38,6.35 106.05,6.35 90.17,22.22 90.17,27.43 88.15,29.45 L9.2 R118.2
TO_TLK1N: length 1.1
  TOP w0.279: C14.1 R21.2
TO_TLK1N1: length 1.2
  TOP w0.279: R19.1 110.83,137.62 C14.2
TO_TLK1P: length 1.1
  TOP w0.279: R13.2 C12.1
TO_TLK1P1: length 1.2
  TOP w0.279: R11.2 110.83,138.61 C12.2
TO_TLK2N: length 1.1
  TOP w0.279: C29.1 R44.2
TO_TLK2N1: length 1.2
  TOP w0.279: R42.1 110.83,99.52 C29.2
TO_TLK2P: length 1.1
  TOP w0.279: R36.2 C27.1
TO_TLK2P1: length 1.2
  TOP w0.279: C27.2 110.83,100.51 R40.1
TO_TLK3N: length 1.1
  TOP w0.279: C44.1 R58.2
TO_TLK3N1: length 1.2
  TOP w0.279: R65.1 110.83,61.42 C44.2
TO_TLK3P: length 1.1
  TOP w0.279: R59.2 C42.1
TO_TLK3P1: length 1.2
  TOP w0.279: R57.2 110.83,62.41 C42.2
TO_TLK4N: length 1.1
  TOP w0.279: C59.1 R90.2
TO_TLK4N1: length 1.2
  TOP w0.279: R92.1 110.83,23.32 C59.2
TO_TLK4P: length 1.1
  TOP w0.279: R82.2 C57.1
TO_TLK4P1: length 1.2
  TOP w0.279: R80.2 110.83,24.31 C57.2

## Copper pours and planes (outline as drawn)
5V on TOP: 83.44,121.03 83.44,125.98 83.57,126.11 89.53,126.11 90.3,125.35 90.3,117.6 91.03,116.87 91.03,115.42 90.07,115.42 89.92,115.57 89.92,116.2 89.41,116.71 87.5,116.71 87.38,116.84 87.38,117.86 87.25,117.98 86.74,117.98 86.61,117.86 86.61,116.84 86.49,116.71 86.23,116.71 86.11,116.84 86.11,120.4 85.72,120.78 83.69,120.78
5V on BOTTOM: 90.3,123.8 90.3,119.51 89.53,118.74 87.02,118.74 86.11,119.66 86.11,121.74 83.44,124.41 83.44,126.01 82.42,127.03 82.42,129.03 85.06,129.03
5V_BARREL on TOP: 93.98,133.73 88.52,133.73 87.63,134.62 87.63,139.7 89.53,141.61 92.71,141.61 94.61,139.7 94.61,134.37
5V_BJ on TOP: 66.04,130.81 66.04,140.34 71.12,145.42 76.2,145.42 85.09,136.53 85.09,129.54 84.45,128.91 67.94,128.91
5V_DIODE on TOP: 88.9,129.54 89.53,128.91 93.34,128.91 93.98,129.54 93.98,132.59 93.6,132.97 89.79,132.97 88.9,132.08
5V_SOURCE on TOP: 85.72,127.89 85.72,132.08 86.36,132.72 87.63,132.72 88.27,132.08 88.27,127.89
GND on TOP (solid shape): 80.64,121.29 80.64,116.2 76.2,111.76 71.12,111.76 66.67,116.2 66.67,121.29 71.12,125.73 76.2,125.73
GND on TOP (solid shape): 108.85,130.66 109.85,126.03 110.86,130.66 110.86,133.46 113.85,133.46 113.85,124.46 105.86,124.46 105.86,133.46 108.85,133.46
GND on TOP (solid shape): 108.85,92.56 109.85,87.93 110.86,92.56 110.86,95.36 113.85,95.36 113.85,86.36 105.86,86.36 105.86,95.36 108.85,95.36
GND on TOP (solid shape): 108.85,54.46 109.85,49.83 110.86,54.46 110.86,57.25 113.85,57.25 113.85,48.25 105.86,48.25 105.86,57.25 108.85,57.25
GND on TOP (solid shape): 108.85,16.3 109.85,11.68 110.86,16.3 110.86,19.1 113.85,19.1 113.85,10.1 105.86,10.1 105.86,19.1 108.85,19.1
GND on TOP (solid shape): 113.85,142.77 110.86,142.77 110.86,145.57 109.85,150.19 108.85,145.57 108.85,142.77 105.86,142.77 105.86,151.77 113.85,151.77
GND on TOP (solid shape): 113.85,104.67 110.86,104.67 110.86,107.47 109.85,112.09 108.85,107.47 108.85,104.67 105.86,104.67 105.86,113.67 113.85,113.67
GND on TOP (solid shape): 113.85,66.57 110.86,66.57 110.86,69.37 109.85,73.99 108.85,69.37 108.85,66.57 105.86,66.57 105.86,75.57 113.85,75.57
GND on TOP (solid shape): 113.85,28.53 110.86,28.53 110.86,31.32 109.85,35.95 108.85,31.32 108.85,28.53 105.86,28.53 105.86,37.53 113.85,37.53
GND on BOTTOM (solid shape): 80.64,121.29 80.64,116.2 76.2,111.76 71.12,111.76 66.67,116.2 66.67,121.29 71.12,125.73 76.2,125.73
GND on L2-GND1 (solid shape): 80.64,121.29 80.64,116.2 76.2,111.76 71.12,111.76 66.67,116.2 66.67,121.29 71.12,125.73 76.2,125.73
GND on L5-GND2 (solid shape): 80.64,121.29 80.64,116.2 76.2,111.76 71.12,111.76 66.67,116.2 66.67,121.29 71.12,125.73 76.2,125.73
GND on TOP: outline of 308 points within 0.63,0.64 142.24,151.64 ; 22 cut-outs
GND on TOP: 135.38,151.26 135.76,151.64 141.1,151.64 142.37,150.37 142.37,150.37 142.37,147.32 136.53,147.32 136.53,145.42 136.4,145.29 135.51,145.29 135.38,145.42
GND on BOTTOM: outline of 118 points within 0.63,0.64 142.37,151.64 ; 7 cut-outs
GND on BOTTOM: 89.53,31.75 90.04,32.26 92.71,32.26 102.87,42.42 123.7,42.42 128.14,46.86 132.21,46.86 132.72,46.36 135.38,46.36 135.89,45.85 135.89,43.69 136.4,43.18 142.37,43.18 142.49,43.05 142.49,13.97 136.4,13.97 135.89,13.46 135.89,11.43 135.25,10.8 132.72,10.8 132.21,10.29 122.05,10.29 118.87,7.11 106.55,7.11 90.81,22.86 90.81,27.94 89.53,29.21
GND on BOTTOM: 117.6,83.31 101.73,83.31 95.88,77.47 90.81,77.47 90.17,78.11 90.17,79.38 98.55,87.76 98.55,107.44 107.31,116.2 112.4,116.2 119.25,123.06 132.21,123.06 132.72,122.55 135.25,122.55 135.89,121.92 135.89,119.76 136.27,119.38 142.37,119.38 142.37,90.3 142.24,90.17 136.4,90.17 135.89,89.66 135.89,87.63 135.25,86.99 132.72,86.99 132.21,86.49 120.78,86.49
GND on L2-GND1: 67.31,0.64 67.31,3.68 64.14,3.68 64.14,40.64 1.91,40.64 0.63,41.91 0.63,106.68 1.78,107.82 64.14,107.82 64.14,148.59 67.44,148.59 67.44,151.77 140.97,151.77 142.37,150.37 142.37,2.03 140.97,0.64 ; 1 cut-out
GND on L5-GND2: 67.31,0.64 67.31,3.68 64.14,3.68 64.14,40.64 1.91,40.64 0.63,41.91 0.63,106.68 1.78,107.82 64.14,107.82 64.14,148.59 67.44,148.59 67.44,151.77 140.97,151.77 142.37,150.37 142.37,1.4 141.61,0.64
3P3V on TOP: 87.38,104.65 87.38,111.76 87.5,111.89 89.28,111.89 90.04,112.65 90.04,113.16 91.06,113.16 91.06,110.36 90.55,109.86 90.55,104.14 87.88,104.14
3P3V on BOTTOM: 90.55,109.86 90.55,104.52 90.17,104.14 87.63,104.14 87,104.77 87,111.76 87.63,112.39 89.53,112.39 90.17,113.03 90.81,113.03 91.44,112.39 91.44,110.74
3P3V on L4-PWR2: 67.94,1.27 67.94,4.32 64.77,4.32 64.77,41.28 5.72,41.28 5.72,45.72 1.27,45.72 1.27,102.87 4.57,102.87 5.08,103.38 5.08,107.31 64.77,107.31 64.77,147.96 68.07,147.96 68.07,151.13 100.08,151.13 100.33,150.88 100.33,20.96 99.69,20.32 76.2,20.32 75.56,19.68 75.56,1.27
3P3V_0034 on TOP: 72.64,102.87 77.09,102.87 77.22,102.74 77.22,99.95 76.96,99.69 72.64,99.69 72.39,99.95 72.39,102.62
3P3V_101 on TOP: 72.64,15.24 77.09,15.24 77.22,15.11 77.22,12.45 76.84,12.07 72.64,12.07 72.39,12.32 72.39,14.99
3P3V_0202 on TOP: 72.64,55.88 77.09,55.88 77.22,55.75 77.22,52.96 76.96,52.7 72.64,52.7 72.39,52.96 72.39,55.63
3P3V_LMH0034 on TOP: 78.99,98.68 78.99,105.03 80.52,105.03 81.03,105.54 82.3,105.54 82.3,100.2 82.68,99.82 82.68,98.55 82.55,98.42 79.25,98.42
3P3V_LMH0034 on BOTTOM: 82.3,104.9 82.3,100.2 82.68,99.82 82.68,98.55 82.55,98.42 79.38,98.42 78.74,99.06 78.74,104.9 79.38,105.54 81.66,105.54
3P3V_LMH0034 on L3-PWR1: 141.73,1.27 67.94,1.27 67.94,4.32 64.77,4.32 64.77,41.28 1.27,41.28 1.27,107.31 64.77,107.31 64.77,147.96 68.07,147.96 68.07,151.13 141.73,151.13
3P3V_LMH0202 on TOP: 78.99,51.69 78.99,58.04 80.52,58.04 81.03,58.55 82.3,58.55 82.3,53.21 82.68,52.83 82.68,51.56 82.55,51.44 79.25,51.44
3P3V_LMH0202 on BOTTOM: 82.3,57.91 82.3,53.21 82.68,52.83 82.68,51.56 82.55,51.44 79.38,51.44 78.74,52.07 78.74,57.91 79.38,58.55 81.66,58.55
3P3V_LMH0202 on L3-PWR1: 71.75,82.55 72.39,83.19 91.44,83.19 92.08,82.55 92.08,27.94 91.44,27.31 72.39,27.31 71.75,27.94
3P3V_LVDS101 on TOP: 78.99,11.05 78.99,17.4 80.52,17.4 81.03,17.91 82.3,17.91 82.3,12.57 82.68,12.19 82.68,10.92 82.55,10.8 79.25,10.8
3P3V_LVDS101 on BOTTOM: 82.3,17.27 82.3,12.57 82.68,12.19 82.68,10.92 82.55,10.8 79.38,10.8 78.74,11.43 78.74,17.27 79.38,17.91 81.66,17.91
3P3V_LVDS101 on L4-PWR2: 141.73,1.27 67.94,1.27 67.94,4.32 64.77,4.32 64.77,41.28 1.27,41.28 1.27,107.31 64.77,107.31 64.77,147.96 68.07,147.96 68.07,151.13 141.73,151.13 ; 2 cut-outs

## Text on the board
BOTTOM: BOTTOM, LAYER 6 | 6
Board Geometry/Soldermask Bottom: SOLDERMASK BOTTOM | 8
Ref Des/Silkscreen Bottom: SILKSCREEN BOTTOM | 10
User.Comments: BJ | 5V | PLUG | +5V | GND | PLACE AND ROUTE ON BOTTOM (2X) | AND PART PLACEMENTS SHOULD BE ADJUSTED AS NECESSARY. | THIS PLACEMENT IS A GENERAL REFERENCE, BUT BOARRD OUTLINES, DIMENSIONS, | USE TLK10081 RJ45 BREAKOUT BOARD AS A REFERENCE | TAKE POWER COMPONENTS FROM TLK10XXX EVM BOARD | (LMN0202) | 6583088 | (SMA'S, LMH0034, LVDS101) | PLACE AND ROUTE ON TOP (4X) | CAMERA 1 INPUT | (MOUNT ON TOP) | MONITOR 1 OUTPUT | (MOUNT ON BOTTOM) | CAMERA 2 INPUT | MONITOR 2 OUTPUT | CAMERA 3 INPUT | MONITOR 3 OUTPUT | CAMERA 4 INPUT | MONITOR 4 OUTPUT
TOP: TOP, LAYER 1 | 1
Board Geometry/Soldermask Top: SOLDERMASK TOP | 7
Ref Des/Silkscreen Top: 3P3V_LVDS101 | 3P3V_LMH0202 | 3P3V_LMH0034 | BANANA | +5V | JACK | 5V | 3P3V | CAM1N | CAM2N | CAM3P | CAM3N | CAM4N | CAM2P | CAM4P | CAM1P | CD/MUTE | MONITOR 3 | MONITOR 4 | MONITOR 2 | MONITOR 1 | SILKSCREEN TOP | 9 | TLK10XXX HD-SDI | INTERFACE BOARD | 6583088
L2-GND1: GND1, LAYER 2 | 2
L3-PWR1: GND2, LAYER 3 | 3
L4-PWR2: GND3, LAYER 4 | 4
L5-GND2: GND4, LAYER 5 | 5
XSECTION_CHART: *  DIELECTRIC - SOLDERMASK_LPI_P8MI 0.8 MIL | *  DIELECTRIC - FILL_2113X2_PCL-370 6.92 MIL | *  DIELECTRIC - CORE_0.150 5.91 MIL | *  DIELECTRIC - CORE_FIL_PCL-370HR 28 MIL | DESIGN CROSS SECTION CHART | ___________________________ | TOTAL THICKNESS 63.78 MIL | 1-6
PAGE_OUTLINE: DRAWN | CHECKED | ENGRG | ISSUED | SIGNATURES | DATE | SCALE | FABRICATION DRAWING | SIZE | NONE | FSCM NO | DWG NO | SHEET | 1 of 1 | REV | DESCRIPTION | REVISIONS | _ | APPROVED | TLK10XXX HD-SDI DAUGHTER BD | TEXAS INSTRUMENTS | D | C | B | A | 7 | 6 | 5 | 4 | 3 | 2 | 1
DIMENSION: FABRICATION | 13 | (1.6 MM +/-10%) | 0.064 +/-10% | SECONDARY SIDE, SILK SCREEN | PRIMARY SIDE, SILK SCREEN | PRIMARY SIDE, SOLDER MASK | PRIMARY SIDE, LAYER 1        0.5 OZ (BEFORE PLATING) | DIELECTRIC                   0.007'' | INNER LAYER 3 GROUND PLANE   1 OZ | SECONDARY SIDE, LAYER 6      0.5 OZ (BEFORE PLATING) | SECONDARY SIDE, SOLDER MASK | INNER LAYER 2 GROUND PLANE   1 OZ | DIELECTRIC                   0.028'' | DIELECTRIC                   0.006'' | INNER LAYER 5 GROUND PLANE   1 OZ | INNER LAYER 4 GROUND PLANE   1 OZ
DISPLAY_BOTTOM: AND MEET OR EXCEED IPC-4552.  2 uIN MIN OF IMMERSION GOLD APPLIED OVER | 120 - 240 uIN OF ELECTROLESS NICKEL. | FABRICATION NOTES: | BEST INDUSTRY PRACTICE IPC-A-600C (COMMERCIAL STANDARD). | PROCESS NOTES: | TRACE WIDTHS AND ROUTING: | 1: COPPER PLATING TO BE 0.001 INCH MINIMUM IN ALL PLATED THROUGH HOLES. | 2: CIRCUITRY ON OUTER LAYERS TO BE ELECTROLESS NICKEL IMMERSION GOLD | 1: ALL FABRICATION ITEMS MUST MEET OR EXCEED | 2: LAMINATE MATERIAL: COPPER CLAD FR4 370 HR or EQUIVALENT. | 3: COPPER WEIGHT: 1.0 OZ MIN OUTER LAYERS / 1.0 OZ INNER LAYERS. | 4: FINISH BOARD THICKNESS: 0.064+/- .010 INCH. | 5: POSITION ACCURACY: +/- .0015 INCH. | 6: WARP AND TWIST NOT TO EXCEED .020/ INCH. | 7: CONTROLLED IMPEDANCE LAYERS: SEE TABLE 1 | 8: LAYER COUNT:6 | 9: VIA PADS FOR ALL UNUSED INTERNAL SIGNAL LAYERS MAY BE REMOVED DURING | BOARD MANUFACTURING. | 3: SOLDERMASK BOTH SIDES, COLOR: BLUE. | 4: APPLY WHITE LPI SILKSCREEN TO TOP AND BOTTOM SIDE OF BOARD USING | 5: THIS BOARD MUST BE RoHS COMPLIANT. | 6. SAMPLE CROSS SECTION MUST BE PROVIDED BY VENDOR. | 1: TRACE WIDTH CALCULATIONS ARE STARTING VALUES. BOARD SHOP MAY | ADJUST TRACE WIDTHS TO COMPENSATE FOR PROCESS. | 2: DIELECTRIC CONSTANT:POLYCLAD 370 HR OR EQUIVALENT. | 7: ALL 10 MIL HOLE VIA PADS SHALL BE TENTED (COVERED WITH SOLDER RESIST). | SEPARATE ARTWORK. | (DIMENSIONS ARE IN INCHES AND [mm])
User.15: SOLDERPASTE TOP | 11
User.16: SOLDERPASTE BOTTOM | 12
User.24: LAYER | NO. | L1(TOP) | L6(BOT) | TABLE 1: | DIMENSIONS: INCHES | 100 +/- 10% | DIFFIRENTIAL PAIR IMPEDANCE (OHMS) | 75 +/- 10% | 50 +/- 10% | SINGLE ENDED | TRACE WIDTH | 0.004 | 0.011 | 0.0055 | DIFF TRACE | WIDTH | 0.006 | SPACING
User.25: FIGURE | SIZE | 10.0 | 24.0 | 38.0 | 44.0 | 120.0 | 140.0 | 255.0 | 50.0 | 130.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +2.0/-2.0 | +3.0/-3.0 | +0.0/-0.0 | PLATED | NON-PLATED | QTY | 1057 | 40 | 6 | 3 | 32 | 2 | 1 | 8
